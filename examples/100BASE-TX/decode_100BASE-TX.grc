options:
  parameters:
    author: lavarenne
    generate_options: qt_gui
    id: decode_100BASETX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: samp_rate/125e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '.5'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 625e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e6
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: oscillo_10Mbps.bin
    type: float
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: Acquisitions100Mbps/output2.bin
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: Acquisitions100Mbps/output.bin
    repeat: 'True'
    type: float
  states: {state: disabled}
- name: blocks_file_source_0_0_1
  id: blocks_file_source
  parameters:
    file: Acquisitions100Mbps/RefCurve_2025-04-10_1_132807.Wfm.bin
    repeat: 'True'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: samp_rate = 500e6
    const: '3'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: samp_rate = 625e6
    const: '3.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: samp_rate = 625e6
    const: '10'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.063'
    max_dev: '1.0'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate/125e6
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: ethernet_fastethernet_descrambler_0
  id: ethernet_fastethernet_descrambler
  parameters:
    idle_run: '40'
    max_idle_no_idle: '100'
    max_in_frame_no_idle: '20000'
    print_debug: 'False'
    search_window: '100'
  states: {}
- name: ethernet_fastethernet_frame_decoder_0
  id: ethernet_fastethernet_frame_decoder
  parameters: {}
  states: {}
- name: ethernet_mlt3_to_scrambled_0
  id: ethernet_mlt3_to_scrambled
  parameters: {}
  states: {}
- name: ethernet_slicer3_0
  id: ethernet_slicer3
  parameters:
    threshold: '0.25'
  states: {}
- name: oscilloscope_oscilloscope_0
  id: oscilloscope_oscilloscope
  parameters:
    channels: '1'
    duration: '200e-6'
    ip: 172.16.15.50
    range: '2'
    rate: samp_rate
    type: '3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    size: '800'
    srate: samp_rate
    type: float
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_file_source_0_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_throttle2_0_0, '0']
- [blocks_multiply_const_vxx_0_0_2, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0_0_2, '0', blocks_throttle2_0_0, '0']
- [blocks_throttle2_0_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [digital_symbol_sync_xx_0, '0', ethernet_slicer3_0, '0']
- [ethernet_fastethernet_descrambler_0, '0', ethernet_fastethernet_frame_decoder_0, '0']
- [ethernet_fastethernet_frame_decoder_0, decoded, zeromq_pub_msg_sink_0, in]
- [ethernet_mlt3_to_scrambled_0, '0', ethernet_fastethernet_descrambler_0, '0']
- [ethernet_slicer3_0, '0', ethernet_mlt3_to_scrambled_0, '0']
- [oscilloscope_oscilloscope_0, '0', blocks_multiply_const_vxx_0_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
