options:
  parameters:
    author: lavarenne
    generate_options: qt_gui
    id: decode_10BASET
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1.25e9
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: oscillo_10Mbps.bin
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: oscillo_10Mbps.bin
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.1'
    init: '0'
    low: '-0.1'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: |-
      Adjust to slow down
      playback speed
    samples_per_second: 1e6/2
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '01100110011001100110011001100110011001100101'
    tagname: packet
    threshold: '0'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '4'
    loop_bw: '0.01'
    max_dev: '0.6'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: 125/10/2
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: ethernet_ethernet_10baset_decoder_0
  id: ethernet_ethernet_10baset_decoder
  parameters:
    tag_name: packet
  states: {}
- name: oscilloscope_oscilloscope_0
  id: oscilloscope_oscilloscope
  parameters:
    channels: '1'
    duration: '200e-6'
    ip: 172.16.15.50
    range: '2'
    rate: samp_rate
    type: '3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '300'
    srate: samp_rate/(125/2)
    tr_delay: '7e-6'
    tr_level: '0.07'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet"'
    type: float
    ymax: '1.2'
    ymin: '-.3'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '25000'
    srate: samp_rate
    tr_delay: '1e-6'
    tr_level: '0.07'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    type: fff
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_uchar_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_throttle2_0, '0', rational_resampler_xxx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_uchar_to_float_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', ethernet_ethernet_10baset_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_threshold_ff_0, '0']
- [ethernet_ethernet_10baset_decoder_0, decoded, zeromq_pub_msg_sink_0, in]
- [oscilloscope_oscilloscope_0, '0', blocks_file_sink_0, '0']
- [oscilloscope_oscilloscope_0, '0', blocks_throttle2_0, '0']
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
